# Keil uVision project camera_back.uvprojx, settings and files
target SY-STM32F407 V2.0 (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: camera_back +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM
  c include: ..\Libraries\CMSIS\inc;..\Libraries\FWlib\inc;..\Startup;..\User;..\Hardware;..\usmart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: include.h main.c stm32f4xx_it.c ctrl.c ctrl.h data_transfer.c data_transfer.h init.c init.h dgp.c dgp.h mymath.c mymath.h
  group Hardware
    ../Hardware/: timer.c timer.h delay.c delay.h led.c led.h ov7670.c ov7670.h ov7670cfg.h pwm_out.c pwm_out.h usart.c usart.h
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_dcmi.c stm32f4xx_syscfg.c
  group CMSIS
    ../Libraries/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Startup/: startup_stm32f4xx.s
software components: CMSIS:CORE 4.1.0
